# Autodesk Inventor assembly: 21.0988 T-SLOT BAR 135
## iProperties
Created: 2006-12
Part Number: 21.0988 T-SLOT BAR 135
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
